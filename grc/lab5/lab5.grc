options:
  parameters:
    generate_options: qt_gui
    id: lab5
    output_language: python
    title: Hamming and n-Repetition
  states: {}

blocks:
- name: R_hamming
  id: variable
  parameters:
    value: 4/7
  states: {}
- name: R_rep
  id: variable
  parameters:
    value: 1/3
  states: {}
- name: dec_rep
  id: variable_repetition_decoder_def
  parameters:
    framebits: frame_size
    ndim: '0'
    prob: '0.5'
    rep: '3'
  states: {}
- name: eb_no_db
  id: variable_qtgui_range
  parameters:
    label: Eb/No (dB)
    orient: Qt.Horizontal
    start: '0'
    step: '0.5'
    stop: '20'
    value: '10'
  states: {}
- name: enc_rep
  id: variable_repetition_encoder_def
  parameters:
    framebits: frame_size
    ndim: '0'
    rep: '3'
  states: {}
- name: reset_ber
  id: variable_qtgui_push_button
  parameters:
    label: Reset BER
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 32e3
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: math.sqrt( 0.5 / ( R_rep * math.pow(10, eb_no_db/10) ) )
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_noise_source_x_0_0_0
  id: analog_noise_source_x
  parameters:
    amp: math.sqrt( 0.5 / ( R_hamming * math.pow(10, eb_no_db/10) ) )
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_noise_source_x_0_0_0_0
  id: analog_noise_source_x
  parameters:
    amp: math.sqrt( 0.5 / ( 1* math.pow(10, eb_no_db/10) ) )
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    maxoutbuf: frame_size
    min: '0'
    minoutbuf: frame_size
    num_samps: frame_size
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_0_0_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_0_0_0_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_char_to_float_0_2_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_2_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_2_0_0_0_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_2_0_0_0_0_1_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_ctrlport_monitor_performance_0
  id: blocks_ctrlport_monitor_performance
  parameters:
    en: 'True'
  states: {state: disabled}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[-1, 1]'
  states: {}
- name: digital_map_bb_0_0_0_0
  id: digital_map_bb
  parameters:
    map: '[-1, 1]'
  states: {}
- name: digital_map_bb_0_0_1_1
  id: digital_map_bb
  parameters:
    map: '[-1, 1]'
  states: {}
- name: digital_map_bb_0_0_1_1_0
  id: digital_map_bb
  parameters:
    map: '[-1, 1]'
  states: {}
- name: fec_extended_decoder_0_1_0
  id: fec_extended_decoder
  parameters:
    decoder_list: dec_rep
    puncpat: puncpat
    threadtype: none
  states: {}
- name: fec_extended_encoder_1_0_0
  id: fec_extended_encoder
  parameters:
    encoder_list: enc_rep
    puncpat: puncpat
    threadtype: none
  states: {}
- name: frame_size
  id: parameter
  parameters:
    label: Frame Size
    type: intx
    value: '4096'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: puncpat
  id: parameter
  parameters:
    value: '''11'''
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: BER
    label2: '# Errors'
    name: '"n-Repetition"'
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_number_sink_0_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: BER
    label2: '# Errors'
    name: '"Hamming (7,4)"'
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_number_sink_0_0_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: BER
    label2: '# Errors'
    name: '"Uncoded"'
    nconnections: '2'
    type: float
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: bits
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: bits
  states: {}
- name: wes_ber_0
  id: wes_ber
  parameters:
    bits_per_byte: '1'
    reset_ber: reset_ber
  states: {}
- name: wes_ber_0_0_0
  id: wes_ber
  parameters:
    bits_per_byte: '1'
    reset_ber: reset_ber
  states: {}
- name: wes_ber_0_0_0_0
  id: wes_ber
  parameters:
    bits_per_byte: '1'
    reset_ber: reset_ber
  states: {}
- name: wes_hamming_decoder_0
  id: wes_hamming_decoder
  parameters:
    frame_size: int(frame_size *7/4)
  states: {}
- name: wes_hamming_encoder_0
  id: wes_hamming_encoder
  parameters:
    frame_size: frame_size
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_noise_source_x_0_0_0, '0', blocks_add_xx_0_0_0, '1']
- [analog_noise_source_x_0_0_0_0, '0', blocks_add_xx_0_0_0_0, '1']
- [analog_random_source_x_0, '0', digital_map_bb_0_0_1_1_0, '0']
- [analog_random_source_x_0, '0', fec_extended_encoder_1_0_0, '0']
- [analog_random_source_x_0, '0', virtual_sink_0_0, '0']
- [analog_random_source_x_0, '0', wes_hamming_encoder_0, '0']
- [blocks_add_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_add_xx_0_0_0, '0', digital_binary_slicer_fb_0_0_0, '0']
- [blocks_add_xx_0_0_0_0, '0', digital_binary_slicer_fb_0_0_0_0, '0']
- [blocks_char_to_float_0_2_0, '0', blocks_add_xx_0, '0']
- [blocks_char_to_float_0_2_0_0, '0', fec_extended_decoder_0_1_0, '0']
- [blocks_char_to_float_0_2_0_0_0_0_1, '0', blocks_add_xx_0_0_0, '0']
- [blocks_char_to_float_0_2_0_0_0_0_1_0, '0', blocks_add_xx_0_0_0_0, '0']
- [digital_binary_slicer_fb_0, '0', digital_map_bb_0, '0']
- [digital_binary_slicer_fb_0_0_0, '0', wes_hamming_decoder_0, '0']
- [digital_binary_slicer_fb_0_0_0_0, '0', wes_ber_0_0_0_0, '1']
- [digital_map_bb_0, '0', blocks_char_to_float_0_2_0_0, '0']
- [digital_map_bb_0_0_0_0, '0', blocks_char_to_float_0_2_0, '0']
- [digital_map_bb_0_0_1_1, '0', blocks_char_to_float_0_2_0_0_0_0_1, '0']
- [digital_map_bb_0_0_1_1_0, '0', blocks_char_to_float_0_2_0_0_0_0_1_0, '0']
- [fec_extended_decoder_0_1_0, '0', wes_ber_0, '0']
- [fec_extended_encoder_1_0_0, '0', digital_map_bb_0_0_0_0, '0']
- [virtual_source_1, '0', wes_ber_0, '1']
- [virtual_source_1, '0', wes_ber_0_0_0, '1']
- [virtual_source_1, '0', wes_ber_0_0_0_0, '0']
- [wes_ber_0, '0', qtgui_number_sink_0, '0']
- [wes_ber_0, '1', qtgui_number_sink_0, '1']
- [wes_ber_0_0_0, '0', qtgui_number_sink_0_0_0, '0']
- [wes_ber_0_0_0, '1', qtgui_number_sink_0_0_0, '1']
- [wes_ber_0_0_0_0, '0', qtgui_number_sink_0_0_0_0, '0']
- [wes_ber_0_0_0_0, '1', qtgui_number_sink_0_0_0_0, '1']
- [wes_hamming_decoder_0, '0', wes_ber_0_0_0, '0']
- [wes_hamming_encoder_0, '0', digital_map_bb_0_0_1_1, '0']

metadata:
  file_format: 1
