options:
  parameters:
    generate_options: qt_gui
    id: lab8
    output_language: python
    title: Lab8
  states: {}

blocks:
- name: const_psk
  id: variable_constellation
  parameters:
    const_points: digital.psk_4()[0]
    dims: '1'
    precision: '8'
    rot_sym: '2'
    sym_map: digital.psk_4()[1]
    type: calcdist
  states: {}
- name: const_qam
  id: variable_constellation
  parameters:
    const_points: digital.qam_16()[0]
    dims: '1'
    precision: '8'
    rot_sym: '2'
    sym_map: digital.qam_16()[1]
    type: calcdist
  states: {}
- name: lw
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: mimo_option
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,6,1,2
    label: MIMO Option
    label0: Alamouti
    label1: MIMO
    num_opts: '2'
    option1: '1'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: npts
  id: variable
  parameters:
    value: '8192'
  states: {}
- name: p_xy
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3,1,3
    label: Correlation Pxy
    orient: Qt.Horizontal
    start: '0'
    step: '0.001'
    stop: '0.99'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: std_dev
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,3
    label: Noise Std. Dev
    orient: Qt.Horizontal
    start: '0'
    step: '0.001'
    stop: '1'
    value: '0.05'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '4'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    type: float
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '4096'
    max_iter: '4096'
    scale: 1/4096
    type: float
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: const_psk.points()
  states: {}
- name: ofdm_alamouti_cc_0
  id: ofdm_alamouti_cc
  parameters:
    mimo_option: mimo_option
    p_xy: p_xy
    std_dev: std_dev
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    alpha2: '0.2'
    grid: 'True'
    gui_hint: tab@0
    marker2: '-1'
    name: '"Correlated Constellation"'
    nconnections: '2'
    size: '1024'
    style2: '2'
    type: complex
    xmax: '4'
    xmin: '-4'
    ymax: '4'
    ymin: '-4'
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    alpha2: '0.2'
    grid: 'True'
    gui_hint: tab@1
    marker2: '-1'
    name: '"De-Correlated Constellation"'
    nconnections: '2'
    size: '1024'
    style2: '2'
    type: complex
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    bins: '200'
    grid: 'True'
    gui_hint: tab@2
    name: '"Histogram"'
    size: npts
    type: float
    width1: '3'
    xmax: '2'
    xmin: '-2'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: 9,0,2,8
    size: '4096'
    srate: '1'
    type: float
    ylabel: Eigenvalue Ratio (dB)
    ymax: '20'
    ymin: '0'
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,0,8,7
    label0: Transmitted
    label1: Received
    label2: Histogram
    num_tabs: '3'
  states: {}

connections:
- [analog_random_source_x_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_histogram_sink_x_0, '0']
- [blocks_deinterleave_0, '0', blocks_divide_xx_0, '0']
- [blocks_deinterleave_0, '1', blocks_divide_xx_0, '1']
- [blocks_divide_xx_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_time_sink_x_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', ofdm_alamouti_cc_0, '0']
- [ofdm_alamouti_cc_0, '0', qtgui_const_sink_x_0, '0']
- [ofdm_alamouti_cc_0, '0', qtgui_const_sink_x_0, '1']
- [ofdm_alamouti_cc_0, '1', blocks_complex_to_real_0, '0']
- [ofdm_alamouti_cc_0, '1', qtgui_const_sink_x_1, '0']
- [ofdm_alamouti_cc_0, '1', qtgui_const_sink_x_1, '1']
- [ofdm_alamouti_cc_0, '2', blocks_deinterleave_0, '0']

metadata:
  file_format: 1
