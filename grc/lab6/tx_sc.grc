options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: tx_sc
    output_language: python
    title: TX Single-Carrier
  states: {}

blocks:
- name: beta
  id: variable_qtgui_range
  parameters:
    gui_hint: 10,0,1,8
    label: Beta (Excess BW)
    orient: Qt.Horizontal
    start: '0.01'
    step: '0.01'
    stop: '0.99'
    value: '0.5'
  states: {}
- name: freqc
  id: variable
  parameters:
    value: 900e6
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,8
    label: RX Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '64'
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: signal_select
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 11,0,1,8
    label: Signal Select
    label0: Rectangular
    label1: Raised Cosine
    label2: Root-Raised Cosine
    num_opts: '3'
    option1: '1'
    option2: '2'
    type: int
    value: '0'
  states: {}
- name: tx_amp
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,8
    label: TX Amplitude
    orient: Qt.Horizontal
    start: '0'
    step: '.001'
    stop: '0.5'
    value: '0.2'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '255'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: tx_amp
    type: complex
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: '2'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: (-1-1j,-1+1j,1-1j,1+1j)
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    auto_filter: 'True'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    frequency: int(freqc)
    samplerate: int(samp_rate)
    uri: usb:1.3.5
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    auto_filter: 'True'
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    frequency: int(freqc)
    gain1: '''manual'''
    manual_gain1: rx_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate/2)
    uri: usb:1.4.5
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_1
  id: import
  parameters:
    imports: from gnuradio.digital.utils import tagged_streams
  states: {}
- name: pulse_shape_hier_0
  id: pulse_shape_hier
  parameters:
    bFilter: signal_select
    rect_taps: (1,1,1,1)
    roll_off: beta
    sps: '4'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate/2
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 2,0,8,8
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-20'
    ymin: '-120'
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_repack_bits_bb_0, '0']
- [blocks_multiply_const_vxx_0, '0', iio_pluto_sink_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', pulse_shape_hier_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [pulse_shape_hier_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
